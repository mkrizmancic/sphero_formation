Commit message: Add more debugging options, resize sphero visuals, add new maps

File: resources/simple_ball.urdf (robot description, URDF)
Before this commit: robot simple_ball, 1 links, 0 joints
Links:
- link base_link: geometry collision sphere radius=0.036; visual sphere radius=0.036
